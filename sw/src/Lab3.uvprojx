# Keil uVision project Lab3.uvprojx, settings and files
target Lab3 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LM4F120H5QR Texas Instruments
  pack: Keil.LM4F_DFP.1.0.0
  cpu: IRAM(0x10000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab3
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  group Source
    ./: startup.s Lab3Main.c SysTick.c Switch_Driver.c Sound_Driver.c LCD_Driver.c LCD_Driver.h Sound_Driver.h Switch_Driver.h Globals.h
    ../inc/: PLL.c Timer0A.c ST7735.c
software components: CMSIS:CORE 5.3.0
